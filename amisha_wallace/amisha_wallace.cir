* C:\Users\Amisha\eSim-Workspace\amisha_wallace\amisha_wallace.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 23-Nov-22 11:19:59 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U5  Net-_U10-Pad9_ Net-_U10-Pad10_ Net-_U10-Pad11_ Net-_U10-Pad12_ Net-_U10-Pad13_ Net-_U10-Pad14_ Net-_U10-Pad15_ Net-_U10-Pad16_ Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ Net-_U11-Pad4_ Net-_U11-Pad5_ Net-_U11-Pad6_ Net-_U11-Pad7_ Net-_U11-Pad8_ amisha_4bit_wallace
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ Net-_U11-Pad4_ Net-_U11-Pad5_ Net-_U11-Pad6_ Net-_U11-Pad7_ Net-_U11-Pad8_ Net-_SC2-Pad2_ Net-_SC6-Pad2_ Net-_SC10-Pad2_ Net-_SC14-Pad2_ Net-_SC15-Pad2_ Net-_SC11-Pad2_ Net-_SC7-Pad2_ Net-_SC3-Pad2_ dac_bridge_8
U10  A3 A2 A1 A0 B3 B2 B1 B0 Net-_U10-Pad9_ Net-_U10-Pad10_ Net-_U10-Pad11_ Net-_U10-Pad12_ Net-_U10-Pad13_ Net-_U10-Pad14_ Net-_U10-Pad15_ Net-_U10-Pad16_ adc_bridge_8
SC3  prod0 Net-_SC3-Pad2_ GND sky130_fd_pr__res_generic_nd
SC7  prod1 Net-_SC7-Pad2_ GND sky130_fd_pr__res_generic_nd
SC11  prod2 Net-_SC11-Pad2_ GND sky130_fd_pr__res_generic_nd
SC15  prod3 Net-_SC15-Pad2_ GND sky130_fd_pr__res_generic_nd
SC2  prod7 Net-_SC2-Pad2_ GND sky130_fd_pr__res_generic_nd
SC6  prod6 Net-_SC6-Pad2_ GND sky130_fd_pr__res_generic_nd
SC10  prod5 Net-_SC10-Pad2_ GND sky130_fd_pr__res_generic_nd
SC14  prod4 Net-_SC14-Pad2_ GND sky130_fd_pr__res_generic_nd
SC4  prod0 GND sky130_fd_pr__cap_mim_m3_1
SC8  prod1 GND sky130_fd_pr__cap_mim_m3_1
SC12  prod2 GND sky130_fd_pr__cap_mim_m3_1
SC16  prod3 GND sky130_fd_pr__cap_mim_m3_1
SC1  prod7 GND sky130_fd_pr__cap_mim_m3_1
SC5  prod6 GND sky130_fd_pr__cap_mim_m3_1
SC9  prod5 GND sky130_fd_pr__cap_mim_m3_1
SC13  prod4 GND sky130_fd_pr__cap_mim_m3_1
v4  A1 GND pulse
v2  A0 GND pulse
v8  B0 GND pulse
v6  B1 GND pulse
v3  B2 GND pulse
v1  B3 GND pulse
v5  A2 GND pulse
v7  A3 GND pulse
U8  A3 plot_v1
U6  A2 plot_v1
U4  A1 plot_v1
U2  A0 plot_v1
U9  B0 plot_v1
U7  B1 plot_v1
U3  B2 plot_v1
U1  B3 plot_v1
U12  prod7 plot_v1
U15  prod6 plot_v1
U17  prod5 plot_v1
U18  prod4 plot_v1
U13  prod0 plot_v1
U14  prod1 plot_v1
U16  prod2 plot_v1
U19  prod3 plot_v1
scmode1  SKY130mode

.end
